SRC_URI = " \
           git://github.com/ampere-openbmc/linux;protocol=https;branch=ampere \
           file://defconfig \
          "

SRCREV="d8f4260fa047bf19eae79eae989358c73e98a0de"
